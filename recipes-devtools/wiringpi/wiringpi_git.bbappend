SRC_URI = "git://github.com/WiringPi/WiringPi.git \
           file://0001-Add-initial-cross-compile-support.patch \
           "
